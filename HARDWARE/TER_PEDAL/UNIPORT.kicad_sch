File: HARDWARE/TER_PEDAL/UNIPORT.kicad_sch (KiCad schematic)
At the start: 1 part, among them J5 RJ45_Shielded

Commit message: Cambio competi resistencia 1.5k
Parts:
- renumbered J5 to J3
